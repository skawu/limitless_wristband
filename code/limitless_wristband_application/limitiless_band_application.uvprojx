# Keil uVision project limitiless_band_application.uvprojx, settings and files
target limitless_applcation (5060061::V5.06 update 1 (build 61)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: nrf52832_xxaa +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __STACK_SIZE=2048 __HEAP_SIZE=1024 NRF_SD_BLE_API_VERSION=3 S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SOFTDEVICE_PRESENT NRF52832 NRF52 FREERTOS
  c include: .\config\ble_app_hrs_freertos_pca10040_s132;.\components;.\components\ble\ble_advertising;.\components\ble\ble_dtm;.\components\ble\ble_racp;.\components\ble\ble_services\ble_ancs_c;.\components\ble\ble_services\ble_ans_c;.\components\ble\ble_services\ble_bas;.\components\ble\ble_services\ble_bas_c;.\components\ble\ble_services\ble_cscs;.\components\ble\ble_services\ble_cts_c;.\components\ble\ble_services\ble_dfu;.\components\ble\ble_services\ble_dis;.\components\ble\ble_services\ble_gls;.\components\ble\ble_services\ble_hids;.\components\ble\ble_services\ble_hrs;.\components\ble\ble_services\ble_hrs_c;.\components\ble\ble_services\ble_hts;.\components\ble\ble_services\ble_ias;.\components\ble\ble_services\ble_ias_c;.\components\ble\ble_services\ble_lbs;.\components\ble\ble_services\ble_lbs_c;.\components\ble\ble_services\ble_lls;.\components\ble\ble_services\ble_nus;.\components\ble\ble_services\ble_nus_c;.\components\ble\ble_services\ble_rscs;.\components\ble\ble_services\ble_rscs_c;.\components\ble\ble_services\ble_tps;.\components\ble\common;.\components\ble\nrf_ble_gatt;.\components\ble\nrf_ble_qwr;.\components\ble\peer_manager;.\components\boards;.\components\drivers_nrf\adc;.\components\drivers_nrf\clock;.\components\drivers_nrf\common;.\components\drivers_nrf\comp;.\components\drivers_nrf\delay;.\components\drivers_nrf\gpiote;.\components\drivers_nrf\hal;.\components\drivers_nrf\i2s;.\components\drivers_nrf\lpcomp;.\components\drivers_nrf\pdm;.\components\drivers_nrf\power;.\components\drivers_nrf\ppi;.\components\drivers_nrf\pwm;.\components\drivers_nrf\qdec;.\components\drivers_nrf\rng;.\components\drivers_nrf\rtc;.\components\drivers_nrf\saadc;.\components\drivers_nrf\spi_master;.\components\drivers_nrf\spi_slave;.\components\drivers_nrf\swi;.\components\drivers_nrf\timer;.\components\drivers_nrf\twi_master;.\components\drivers_nrf\twis_slave;.\components\drivers_nrf\uart;.\components\drivers_nrf\usbd;.\components\drivers_nrf\wdt;.\components\libraries\bsp;.\components\libraries\button;.\components\libraries\crc16;.\components\libraries\crc32;.\components\libraries\csense;.\components\libraries\csense_drv;.\components\libraries\experimental_section_vars;.\components\libraries\fds;.\components\libraries\fstorage;.\components\libraries\gpiote;.\components\libraries\hardfault;.\components\libraries\hardfault\nrf52;.\components\libraries\hci;.\components\libraries\led_softblink;.\components\libraries\log;.\components\libraries\log\src;.\components\libraries\low_power_pwm;.\components\libraries\mem_manager;.\components\libraries\pwm;.\components\libraries\queue;.\components\libraries\scheduler;.\components\libraries\sensorsim;.\components\libraries\slip;.\components\libraries\timer;.\components\libraries\twi;.\components\libraries\uart;.\components\libraries\usbd;.\components\libraries\usbd\class\audio;.\components\libraries\usbd\class\cdc;.\components\libraries\usbd\class\cdc\acm;.\components\libraries\usbd\class\hid;.\components\libraries\usbd\class\hid\generic;.\components\libraries\usbd\class\hid\kbd;.\components\libraries\usbd\class\hid\mouse;.\components\libraries\usbd\class\msc;.\components\libraries\usbd\config;.\components\libraries\util;.\components\softdevice\common\softdevice_handler;.\components\softdevice\s132\headers;.\components\softdevice\s132\headers\nrf52;.\components\toolchain;.\components\external\freertos\config;.\components\external\freertos\portable\ARM\nrf52;.\components\external\freertos\portable\CMSIS\nrf52;.\components\external\freertos\source\include;.\components\external\segger_rtt;.\config;.\config\RTE\_nrf52832_xxaa;.\config\RTE\Device\nRF52832_xxAA;.\config;.\USER;.\USER\oled;.\USER\w25q128
  asm define: as above
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__STACK_SIZE=2048,-D__HEAP_SIZE=1024,-DNRF_SD_BLE_API_VERSION=3,-DS132,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DFREERTOS
  asm include: ..\config\ble_app_hrs_freertos_pca10040_s132;.\components;.\components\ble\ble_advertising;.\components\ble\ble_dtm;.\components\ble\ble_racp;.\components\ble\ble_services\ble_ancs_c;.\components\ble\ble_services\ble_ans_c;.\components\ble\ble_services\ble_bas;.\components\ble\ble_services\ble_bas_c;.\components\ble\ble_services\ble_cscs;.\components\ble\ble_services\ble_cts_c;.\components\ble\ble_services\ble_dfu;.\components\ble\ble_services\ble_dis;.\components\ble\ble_services\ble_gls;.\components\ble\ble_services\ble_hids;.\components\ble\ble_services\ble_hrs;.\components\ble\ble_services\ble_hrs_c;.\components\ble\ble_services\ble_hts;.\components\ble\ble_services\ble_ias;.\components\ble\ble_services\ble_ias_c;.\components\ble\ble_services\ble_lbs;.\components\ble\ble_services\ble_lbs_c;.\components\ble\ble_services\ble_lls;.\components\ble\ble_services\ble_nus;.\components\ble\ble_services\ble_nus_c;.\components\ble\ble_services\ble_rscs;.\components\ble\ble_services\ble_rscs_c;.\components\ble\ble_services\ble_tps;.\components\ble\common;.\components\ble\nrf_ble_gatt;.\components\ble\nrf_ble_qwr;.\components\ble\peer_manager;.\components\boards;.\components\drivers_nrf\adc;.\components\drivers_nrf\clock;.\components\drivers_nrf\common;.\components\drivers_nrf\comp;.\components\drivers_nrf\delay;.\components\drivers_nrf\gpiote;.\components\drivers_nrf\hal;.\components\drivers_nrf\i2s;.\components\drivers_nrf\lpcomp;.\components\drivers_nrf\pdm;.\components\drivers_nrf\power;.\components\drivers_nrf\ppi;.\components\drivers_nrf\pwm;.\components\drivers_nrf\qdec;.\components\drivers_nrf\rng;.\components\drivers_nrf\rtc;.\components\drivers_nrf\saadc;.\components\drivers_nrf\spi_master;.\components\drivers_nrf\spi_slave;.\components\drivers_nrf\swi;.\components\drivers_nrf\timer;.\components\drivers_nrf\twi_master;.\components\drivers_nrf\twis_slave;.\components\drivers_nrf\uart;.\components\drivers_nrf\usbd;.\components\drivers_nrf\wdt;.\components\libraries\bsp;.\components\libraries\button;.\components\libraries\crc16;.\components\libraries\crc32;.\components\libraries\csense;.\components\libraries\csense_drv;.\components\libraries\experimental_section_vars;.\components\libraries\fds;.\components\libraries\fstorage;.\components\libraries\gpiote;.\components\libraries\hardfault;.\components\libraries\hardfault\nrf52;.\components\libraries\hci;.\components\libraries\led_softblink;.\components\libraries\log;.\components\libraries\log\src;.\components\libraries\low_power_pwm;.\components\libraries\mem_manager;.\components\libraries\pwm;.\components\libraries\queue;.\components\libraries\scheduler;.\components\libraries\sensorsim;.\components\libraries\slip;.\components\libraries\timer;.\components\libraries\twi;.\components\libraries\uart;.\components\libraries\usbd;.\components\libraries\usbd\class\audio;.\components\libraries\usbd\class\cdc;.\components\libraries\usbd\class\cdc\acm;.\components\libraries\usbd\class\hid;.\components\libraries\usbd\class\hid\generic;.\components\libraries\usbd\class\hid\kbd;.\components\libraries\usbd\class\hid\mouse;.\components\libraries\usbd\class\msc;.\components\libraries\usbd\config;.\components\libraries\util;.\components\softdevice\common\softdevice_handler;.\components\softdevice\s132\headers;.\components\softdevice\s132\headers\nrf52;.\components\toolchain;.\components\external\freertos\config;.\components\external\freertos\portable\ARM\nrf52;.\components\external\freertos\portable\CMSIS\nrf52;.\components\external\freertos\source\include;.\components\external\segger_rtt;.\config;.\config\RTE\_nrf52832_xxaa;.\config\RTE\Device\nRF52832_xxAA;.\config
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
  group Application
    ./USER/: main.c
    ./config/: sdk_config.h
  group limitiless_board
    ./components/boards/: boards.c
  group limitiless_bsp
    ./components/libraries/bsp/: bsp.c bsp_btn_ble.c bsp_nfc.c
  group limitiless_freerots
    ./components/external/freertos/source/: timers.c tasks.c croutine.c event_groups.c list.c queue.c
    ./components/external/freertos/source/portable/MemMang/: heap_1.c
    ./components/external/freertos/portable/ARM/nrf52/: port.c
    ./components/external/freertos/portable/CMSIS/nrf52/: port_cmsis.c port_cmsis_systick.c
  group limitiless_common
    ./components/ble/ble_advertising/: ble_advertising.c
    ./components/ble/common/: ble_conn_params.c ble_conn_state.c ble_srv_common.c ble_advdata.c
    ./components/ble/peer_manager/: gatt_cache_manager.c gatts_cache_manager.c id_manager.c peer_data.c peer_data_storage.c peer_database.c peer_id.c peer_manager.c pm_buffer.c pm_mutex.c security_dispatcher.c security_manager.c
    ./components/ble/nrf_ble_gatt/: nrf_ble_gatt.c
  group limitiless_ble_service
    ./components/ble/ble_services/ble_bas/: ble_bas.c
    ./components/ble/ble_services/ble_dis/: ble_dis.c
    ./components/ble/ble_services/ble_hrs/: ble_hrs.c
  group limitiless_ble_driver
    ./components/drivers_nrf/clock/: nrf_drv_clock.c
    ./components/drivers_nrf/common/: nrf_drv_common.c
    ./components/drivers_nrf/gpiote/: nrf_drv_gpiote.c
    ./components/drivers_nrf/uart/: nrf_drv_uart.c
    ./components/drivers_nrf/spi_master/: nrf_drv_spi.c
  group limitiless_ble_lib
    ./components/libraries/button/: app_button.c
    ./components/libraries/util/: app_error.c app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c sdk_mapped_flags.c
    ./components/libraries/timer/: app_timer_freertos.c
    ./components/libraries/crc16/: crc16.c
    ./components/libraries/fds/: fds.c
    ./components/libraries/fstorage/: fstorage.c
    ./components/libraries/hardfault/nrf52/handler/: hardfault_handler_keil.c
    ./components/libraries/hardfault/: hardfault_implementation.c
    ./components/libraries/sensorsim/: sensorsim.c
  group limitiless_log
    ./components/external/segger_rtt/: RTT_Syscalls_KEIL.c SEGGER_RTT_printf.c SEGGER_RTT.c
    ./components/libraries/log/src/: nrf_log_backend_serial.c nrf_log_frontend.c
  group limitiless_softdevice
    ./components/softdevice/common/softdevice_handler/: softdevice_handler.c
  group oled
    ./USER/oled/: oled_drv.c gui_drv.c
  group w25q128
    ./USER/w25q128/: w25q128_drv.c
target limitless_softdevice (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.5.0
  cpu: as above
  output: limitless_softdevice.hex +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: as above
  c include: .\config\ble_app_hrs_freertos_pca10040_s132;.\components;.\components\ble\ble_advertising;.\components\ble\ble_dtm;.\components\ble\ble_racp;.\components\ble\ble_services\ble_ancs_c;.\components\ble\ble_services\ble_ans_c;.\components\ble\ble_services\ble_bas;.\components\ble\ble_services\ble_bas_c;.\components\ble\ble_services\ble_cscs;.\components\ble\ble_services\ble_cts_c;.\components\ble\ble_services\ble_dfu;.\components\ble\ble_services\ble_dis;.\components\ble\ble_services\ble_gls;.\components\ble\ble_services\ble_hids;.\components\ble\ble_services\ble_hrs;.\components\ble\ble_services\ble_hrs_c;.\components\ble\ble_services\ble_hts;.\components\ble\ble_services\ble_ias;.\components\ble\ble_services\ble_ias_c;.\components\ble\ble_services\ble_lbs;.\components\ble\ble_services\ble_lbs_c;.\components\ble\ble_services\ble_lls;.\components\ble\ble_services\ble_nus;.\components\ble\ble_services\ble_nus_c;.\components\ble\ble_services\ble_rscs;.\components\ble\ble_services\ble_rscs_c;.\components\ble\ble_services\ble_tps;.\components\ble\common;.\components\ble\nrf_ble_gatt;.\components\ble\nrf_ble_qwr;.\components\ble\peer_manager;.\components\boards;.\components\drivers_nrf\adc;.\components\drivers_nrf\clock;.\components\drivers_nrf\common;.\components\drivers_nrf\comp;.\components\drivers_nrf\delay;.\components\drivers_nrf\gpiote;.\components\drivers_nrf\hal;.\components\drivers_nrf\i2s;.\components\drivers_nrf\lpcomp;.\components\drivers_nrf\pdm;.\components\drivers_nrf\power;.\components\drivers_nrf\ppi;.\components\drivers_nrf\pwm;.\components\drivers_nrf\qdec;.\components\drivers_nrf\rng;.\components\drivers_nrf\rtc;.\components\drivers_nrf\saadc;.\components\drivers_nrf\spi_master;.\components\drivers_nrf\spi_slave;.\components\drivers_nrf\swi;.\components\drivers_nrf\timer;.\components\drivers_nrf\twi_master;.\components\drivers_nrf\twis_slave;.\components\drivers_nrf\uart;.\components\drivers_nrf\usbd;.\components\drivers_nrf\wdt;.\components\libraries\bsp;.\components\libraries\button;.\components\libraries\crc16;.\components\libraries\crc32;.\components\libraries\csense;.\components\libraries\csense_drv;.\components\libraries\experimental_section_vars;.\components\libraries\fds;.\components\libraries\fstorage;.\components\libraries\gpiote;.\components\libraries\hardfault;.\components\libraries\hardfault\nrf52;.\components\libraries\hci;.\components\libraries\led_softblink;.\components\libraries\log;.\components\libraries\log\src;.\components\libraries\low_power_pwm;.\components\libraries\mem_manager;.\components\libraries\pwm;.\components\libraries\queue;.\components\libraries\scheduler;.\components\libraries\sensorsim;.\components\libraries\slip;.\components\libraries\timer;.\components\libraries\twi;.\components\libraries\uart;.\components\libraries\usbd;.\components\libraries\usbd\class\audio;.\components\libraries\usbd\class\cdc;.\components\libraries\usbd\class\cdc\acm;.\components\libraries\usbd\class\hid;.\components\libraries\usbd\class\hid\generic;.\components\libraries\usbd\class\hid\kbd;.\components\libraries\usbd\class\hid\mouse;.\components\libraries\usbd\class\msc;.\components\libraries\usbd\config;.\components\libraries\util;.\components\softdevice\common\softdevice_handler;.\components\softdevice\s132\headers;.\components\softdevice\s132\headers\nrf52;.\components\toolchain;.\components\external\freertos\config;.\components\external\freertos\portable\ARM\nrf52;.\components\external\freertos\portable\CMSIS\nrf52;.\components\external\freertos\source\include;.\components\external\segger_rtt;.\config;.\config\RTE\_nrf52832_xxaa;.\config\RTE\Device\nRF52832_xxAA;.\config;.\USER
  asm define: as above
  asm misc: as above
  asm include: as above
  library: MicroLIB
  memory RVCT4: ROM 0x1f000 size 0x61000
  memory RVCT9: RAM 0x20002128 size 0xded8
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
