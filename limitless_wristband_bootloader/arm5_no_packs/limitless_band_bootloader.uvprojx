# Keil uVision project limitless_band_bootloader.uvprojx, settings and files
target limitless_bootloader (5060183::V5.06 update 2 (build 183)::ARMCC)
  device: nRF52832_xxAA Nordic Semiconductor
  pack: NordicSemiconductor.nRF_DeviceFamilyPack.8.15.0
  cpu: IROM(0x00000000,0x80000) IRAM(0x20000000,0x10000) CPUTYPE("Cortex-M4") FPU2 CLOCK(64000000) ELITTLE
  output: limitless_bootloader +hex
  c flags: Optim=4 OneElfS=1 uC99=1
  c define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION NRF_SD_BLE_API_VERSION=3 S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52 NRF_DFU_SETTINGS_VERSION=1 NRF_DFU_DEBUG_VERSION
  c include: ..\..\config\secure_dfu_secure_dfu_ble_s132_pca10040;..\..\config;..\..\limitless_wristband_application\code\components;..\..\limitless_wristband_application\code\components\ble\common;..\..\limitless_wristband_application\code\components\boards;..\..\limitless_wristband_application\code\components\drivers_nrf\clock;..\..\limitless_wristband_application\code\components\drivers_nrf\common;..\..\limitless_wristband_application\code\components\drivers_nrf\delay;..\..\limitless_wristband_application\code\components\drivers_nrf\hal;..\..\limitless_wristband_application\code\components\drivers_nrf\rng;..\..\limitless_wristband_application\code\components\libraries\bootloader;..\..\limitless_wristband_application\code\components\libraries\bootloader\ble_dfu;..\..\limitless_wristband_application\code\components\libraries\bootloader\dfu;..\..\limitless_wristband_application\code\components\libraries\crc32;..\..\limitless_wristband_application\code\components\libraries\crypto;..\..\limitless_wristband_application\code\components\libraries\experimental_section_vars;..\..\limitless_wristband_application\code\components\libraries\fstorage;..\..\limitless_wristband_application\code\components\libraries\ecc;..\..\limitless_wristband_application\code\components\libraries\hci;..\..\limitless_wristband_application\code\components\libraries\log;..\..\limitless_wristband_application\code\components\libraries\log\src;..\..\limitless_wristband_application\code\components\libraries\queue;..\..\limitless_wristband_application\code\components\libraries\scheduler;..\..\limitless_wristband_application\code\components\libraries\sha256;..\..\limitless_wristband_application\code\components\libraries\svc;..\..\limitless_wristband_application\code\components\libraries\timer;..\..\limitless_wristband_application\code\components\libraries\util;..\..\limitless_wristband_application\code\components\softdevice\common\softdevice_handler;..\..\limitless_wristband_application\code\components\softdevice\s132\headers;..\..\limitless_wristband_application\code\components\softdevice\s132\headers\nrf52;..\..\limitless_wristband_application\code\components\toolchain;..\external\micro-ecc\micro-ecc;..\external\nano-pb;..\config
  asm define: BLE_STACK_SUPPORT_REQD __HEAP_SIZE=0 SVC_INTERFACE_CALL_AS_NORMAL_FUNCTION NRF_SD_BLE_API_VERSION=3 S132 BOARD_PCA10040 NRF52_PAN_12 NRF52_PAN_15 NRF52_PAN_20 NRF52_PAN_31 NRF52_PAN_36 NRF52_PAN_51 CONFIG_GPIO_AS_PINRESET NRF52_PAN_54 NRF52_PAN_55 NRF52_PAN_58 NRF52_PAN_64 SWI_DISABLE0 SOFTDEVICE_PRESENT NRF52832 NRF52 NRF_DFU_SETTINGS_VERSION=1
  asm misc: --cpreproc_opts=-DBLE_STACK_SUPPORT_REQD,-D__HEAP_SIZE=0,-DSVC_INTERFACE_CALL_AS_NORMAL_FUNCTION,-DNRF_SD_BLE_API_VERSION=3,-DS132,-DBOARD_PCA10040,-DNRF52_PAN_12,-DNRF52_PAN_15,-DNRF52_PAN_20,-DNRF52_PAN_31,-DNRF52_PAN_36,-DNRF52_PAN_51,-DCONFIG_GPIO_AS_PINRESET,-DNRF52_PAN_54,-DNRF52_PAN_55,-DNRF52_PAN_58,-DNRF52_PAN_64,-DSWI_DISABLE0,-DSOFTDEVICE_PRESENT,-DNRF52832,-DNRF52,-DNRF_DFU_SETTINGS_VERSION=1
  asm include: ..\..\config\secure_dfu_secure_dfu_ble_s132_pca10040;..\..\config;..\..\..\..\..\components;..\..\..\..\..\components\ble\common;..\..\..\..\..\components\boards;..\..\..\..\..\components\drivers_nrf\clock;..\..\..\..\..\components\drivers_nrf\common;..\..\..\..\..\components\drivers_nrf\delay;..\..\..\..\..\components\drivers_nrf\hal;..\..\..\..\..\components\drivers_nrf\rng;..\..\..\..\..\components\libraries\bootloader;..\..\..\..\..\components\libraries\bootloader\ble_dfu;..\..\..\..\..\components\libraries\bootloader\dfu;..\..\..\..\..\components\libraries\crc32;..\..\..\..\..\components\libraries\crypto;..\..\..\..\..\components\libraries\ecc;..\..\..\..\..\components\libraries\experimental_section_vars;..\..\..\..\..\components\libraries\fstorage;..\..\..\..\..\components\libraries\hci;..\..\..\..\..\components\libraries\log;..\..\..\..\..\components\libraries\log\src;..\..\..\..\..\components\libraries\queue;..\..\..\..\..\components\libraries\scheduler;..\..\..\..\..\components\libraries\sha256;..\..\..\..\..\components\libraries\svc;..\..\..\..\..\components\libraries\timer;..\..\..\..\..\components\libraries\util;..\..\..\..\..\components\softdevice\common\softdevice_handler;..\..\..\..\..\components\softdevice\s132\headers;..\..\..\..\..\components\softdevice\s132\headers\nrf52;..\..\..\..\..\components\toolchain;..\..;..\..\..\..\..\external\micro-ecc\micro-ecc;..\..\..\..\..\external\nano-pb;..\config
  library: MicroLIB
  memory RVCT4: ROM 0x78000 size 0x6000
  memory RVCT9: RAM 0x20002c00 size 0xd380
  group limitless_application
    ../: dfu-cc.pb.c dfu_public_key.c dfu_req_handling.c main.c
    ../config/: sdk_config.h
  group limitless_board
    ../../limitless_wristband_application/code/components/boards/: boards.c
  group limitless_ble
    ../../limitless_wristband_application/code/components/ble/common/: ble_advdata.c ble_conn_params.c ble_srv_common.c
  group limitless_ble_dfu
    ../../limitless_wristband_application/code/components/libraries/bootloader/ble_dfu/: nrf_ble_dfu.c
  group limitless_bootloader
    ../../limitless_wristband_application/code/components/libraries/bootloader/: nrf_bootloader.c nrf_bootloader_app_start.c nrf_bootloader_info.c
    ../../limitless_wristband_application/code/components/libraries/bootloader/dfu/: nrf_dfu.c nrf_dfu_flash.c nrf_dfu_mbr.c nrf_dfu_settings.c nrf_dfu_transport.c nrf_dfu_utils.c
  group limitless_driver
    ../../limitless_wristband_application/code/components/drivers_nrf/common/: nrf_drv_common.c
    ../../limitless_wristband_application/code/components/drivers_nrf/rng/: nrf_drv_rng.c
    ../../limitless_wristband_application/code/components/drivers_nrf/hal/: nrf_nvmc.c
  group limitless_libraries
    ../../limitless_wristband_application/code/components/libraries/util/: app_error_weak.c app_util_platform.c nrf_assert.c sdk_errors.c
    ../../limitless_wristband_application/code/components/libraries/scheduler/: app_scheduler.c
    ../../limitless_wristband_application/code/components/libraries/timer/: app_timer.c app_timer_appsh.c
    ../../limitless_wristband_application/code/components/libraries/crc32/: crc32.c
    ../../limitless_wristband_application/code/components/libraries/ecc/: ecc.c
    ../../limitless_wristband_application/code/components/libraries/fstorage/: fstorage.c
    ../../limitless_wristband_application/code/components/libraries/hci/: hci_mem_pool.c
    ../../limitless_wristband_application/code/components/libraries/crypto/: nrf_crypto.c
    ../../limitless_wristband_application/code/components/libraries/queue/: nrf_queue.c
    ../../limitless_wristband_application/code/components/libraries/sha256/: sha256.c
  group limitless_softdevice
    ../../limitless_wristband_application/code/components/softdevice/common/softdevice_handler/: softdevice_handler.c softdevice_handler_appsh.c
  group limitless__micro_ecc
    ../external/micro-ecc/nrf52_keil/armgcc/: micro_ecc_lib_nrf52.lib
  group limitless_nano-pb
    ../external/nano-pb/: pb_common.c pb_decode.c
software components: CMSIS:CORE 4.3.0, Device:Startup 8.11.1
